# Keil uVision project DES_M0_SoC_Basic_Uart.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: DES_M0_SoC +hex
  AfterMake: fromelf .\temp_files\DES_M0_SoC.axf --vhx --32x1 -o ROMcode.hex
  AfterMake: fromelf -cvf .\temp_files\DES_M0_SoC.axf -o .\temp_files\disasm.txt
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group New Group
    ./: DES_M0_SoC.h main.c adxl.c adxl.h cm0dsasm.s display.c display.h retarget.c spi.c spi.h util.c util.h
